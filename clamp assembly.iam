# Autodesk Inventor assembly: clamp assembly
## iProperties
Created: 2006-04
Part Number: clamp assembly
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
