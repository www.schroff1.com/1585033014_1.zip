# Autodesk Inventor assembly: tsw_103_08_x_d
## iProperties
Created: 2006-03
Part Number: tsw_103_08_x_d
Document SubType Name: Assembly
Designer: Elise Moss
Author: Elise Moss
