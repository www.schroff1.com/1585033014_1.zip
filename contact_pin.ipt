# Autodesk Inventor part: contact_pin
## iProperties
Created: 2006-03
Part Number: contact_pin
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Base1
