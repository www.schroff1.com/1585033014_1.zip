# Autodesk Inventor assembly: c-clamp
## iProperties
Created: 2006-04
Part Number: c-clamp
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
