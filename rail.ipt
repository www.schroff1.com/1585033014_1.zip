# Autodesk Inventor part: rail
## iProperties
Created: 2006-04
Part Number: rail
Document SubType Name: Modeling
Designer: E. MOSS
Author: E. MOSS
## Feature names
1. Extrusion1
2. Hole1
