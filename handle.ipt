# Autodesk Inventor part: handle
## iProperties
Created: 2006-04
Part Number: handle
Document SubType Name: Modeling
Designer: E. MOSS
Author: E. MOSS
## Feature names
1. Revolution1
2. Fillet1
