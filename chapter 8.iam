# Autodesk Inventor assembly: chapter 8
## iProperties
Created: 2006-03
Part Number: chapter 8
Document SubType Name: Assembly
Designer: Elise Moss
Author: Elise Moss
